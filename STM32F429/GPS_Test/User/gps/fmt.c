/**
 ******************************************************************************
 * @file    fmt.c
 * @brief   坐标格式化实现（纯 C，整数运算，可 PC 单测）
 ******************************************************************************
 */
#include "fmt.h"

#include <stdio.h>

void Fmt_E7(char *buf, int n, int32_t e7)
{
    int32_t a = (e7 < 0) ? -e7 : e7;

    if (buf == 0 || n <= 0) { return; }

    snprintf(buf, (size_t)n, "%s%ld.%07ld",
             (e7 < 0) ? "-" : "",
             (long)(a / 10000000), (long)(a % 10000000));
}

void Fmt_Dms(char *buf, int n, int32_t e7, char pos, char neg)
{
    int32_t a;      /* 绝对值，单位 1e-7 度 */
    int32_t deg;    /* 度 */
    int32_t rem;    /* 去掉度之后剩下的，单位 1e-7 度 */
    int32_t min;    /* 分：rem * 60 / 1e7 */
    int32_t sec10;  /* 秒 ×10，用来保留一位小数 */

    if (buf == 0 || n <= 0) { return; }

    a   = (e7 < 0) ? -e7 : e7;
    deg = a / 10000000;
    rem = a % 10000000;

    /* rem 最大 9,999,999；乘 60 得 599,999,940，在 int32 范围内（上限 2.1e9）*/
    min = (rem * 60) / 10000000;

    /* 余下的（不足一分的小数部分）再乘 60 得到秒 ×10。
     * 加 500000 是四舍五入到 0.1 秒 —— 直接截断会让 29.9999 秒显示成 29.9。
     * (rem*60 % 1e7) 最大 1e7，乘 60 得 6e8，加 5e5 仍在 int32 范围内 */
    sec10 = (((rem * 60) % 10000000) * 60 + 500000) / 1000000;

    /* 秒进位保护：42.96 秒可能被算成 42.9；不会到 60，但保险起见处理一下 */
    if (sec10 >= 600)
    {
        sec10 -= 600;
        min++;

        if (min >= 60)
        {
            min -= 60;
            deg++;
        }
    }

    snprintf(buf, (size_t)n, "%ldd%02ld'%02ld.%ld\"%c",
             (long)deg,
             (long)min,
             (long)(sec10 / 10),
             (long)(sec10 % 10),
             (e7 < 0) ? neg : pos);
}
